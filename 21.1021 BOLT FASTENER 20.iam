# Autodesk Inventor assembly: 21.1021 BOLT FASTENER 20
## iProperties
Created: 2006-12
Part Number: 21.1021 BOLT FASTENER 20
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
